options:
  parameters:
    author: Leocarlos Bezerra da Silva Lima
    category: Custom
    description: Experimento para Laboratório de Princípios de Comunicações. Departamento de Engenharia Elétrica - DEE da Universidade Federal de Campina Grande - UFCG.
    generate_options: qt_gui
    id: Labo1_2
    output_language: python
    title: Geracao de sinal a partir de sua serie de Fourier
  states: {}

blocks:
- name: A1
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tab@0: [0,0,1,2]'
    label: Amplitude 1
    start: '-1.5'
    step: '0.01'
    stop: '1.5'
    value: '0'
  states: {}
- name: A2
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tab@0: [1,0,1,2]'
    label: Amplitude 2
    start: '-1.5'
    step: '0.01'
    stop: '1.5'
    value: '0'
  states: {}
- name: A3
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tab@0: [2,0,1,2]'
    label: Amplitude 3
    start: '-1.5'
    step: '0.01'
    stop: '1.5'
    value: '0'
  states: {}
- name: f0
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tab@1: [0,0,1,2]'
    label: fundamental
    start: '0'
    step: '50'
    stop: '1500'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: Tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,2,2
    label0: Amplitudes
    label1: Frequencia
    num_tabs: '2'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: fundamental
  id: analog_sig_source_x
  parameters:
    amp: A1
    freq: f0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: graf_tempo_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: harmonica_1
  id: analog_sig_source_x
  parameters:
    amp: A2
    freq: 3*f0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: harmonica_2
  id: analog_sig_source_x
  parameters:
    amp: A3
    freq: 5*f0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: float
  states: {}
- name: somador_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', somador_0, '0']
- [blocks_throttle_0_0, '0', somador_0, '2']
- [blocks_throttle_0_1, '0', somador_0, '1']
- [fundamental, '0', blocks_throttle_0, '0']
- [harmonica_1, '0', blocks_throttle_0_1, '0']
- [harmonica_2, '0', blocks_throttle_0_0, '0']
- [somador_0, '0', graf_tempo_0, '0']
- [somador_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
